/**************************************************************************
 * File Name: led.c
 * Description : LED Control Code
 * Writer: supeurpon@126.com
 * Revision: 

    |--------------------|
    |  TEST-PB5          |
    |--------------------|
****************************************************************************************/
#include "led.h"


/**************************************************************************
 * Function: LED_Conf 
 * Description: Configure LED Port
 *************************************************************************/
void LED_Conf(void)
{
  PB_DDR |= 0x20;
  PB_CR1 |= 0x20;
  PB_CR2 |= 0x00;
}

/**************************************************************************
 * Function: LED_On 
 *************************************************************************/
void LED_On(void)
{
  PB_ODR &= ~0x20;
}

/**************************************************************************
 * Led_Off
 *************************************************************************/
void LED_Off(void)
{
  PB_ODR |= 0x20;
}

/**************************************************************************
 * Function: Delay
 * Input:  nCount
 *************************************************************************/
void Delay(u32 nCount)
{
  /* Decrement nCount value */
  while (nCount != 0)
  {
    nCount--;
  }
}
/************************************************************************
 * Blink
 * Input: speed(1, 2, 3)
 ***********************************************************************/
void Blink(u8 speed)
{
  u8 i, j;
  for(j = 0; j < 2; j++)
  {
    LED_On();
    for(i = 0; i < 10*speed; i++)
      Delay(2000);
    LED_Off();
    for(i = 0; i < 10*speed; i++)
      Delay(2000);
  }
}